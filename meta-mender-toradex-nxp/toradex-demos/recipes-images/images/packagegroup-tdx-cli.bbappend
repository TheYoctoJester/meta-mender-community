RRECOMMENDS:packagegroup-base-tdx-cli:remove:mender-grub = "\
    u-boot-fw-utils \
"
