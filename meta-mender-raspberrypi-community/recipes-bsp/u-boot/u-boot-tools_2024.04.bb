require u-boot-common.inc
require u-boot-tools.inc

COMPATIBLE_MACHINE = "raspberrypi5"