VOLATILE_BINDS:pn-volatile-binds = "\
  /data/overlay/home /home\n\
  /data/overlay/lib/var /var/lib\n\
  ${localstatedir}/volatile/cache ${localstatedir}/cache\n\
  ${localstatedir}/volatile/spool ${localstatedir}/spool\n\
  ${localstatedir}/volatile/srv /srv\n\
"